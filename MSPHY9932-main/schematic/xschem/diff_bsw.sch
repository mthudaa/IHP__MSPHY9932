v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {single_bsw.sym} 330 -280 0 0 {name=x1}
C {single_bsw.sym} 330 -160 0 0 {name=x2}
C {lab_pin.sym} 180 -310 0 0 {name=p1 lab=vip}
C {lab_pin.sym} 180 -290 0 0 {name=p2 lab=ck}
C {lab_pin.sym} 180 -270 0 0 {name=p3 lab=vdd}
C {lab_pin.sym} 180 -250 0 0 {name=p4 lab=vss}
C {lab_pin.sym} 480 -310 0 1 {name=p5 lab=vcp}
C {lab_pin.sym} 180 -190 0 0 {name=p6 lab=vin}
C {lab_pin.sym} 180 -170 0 0 {name=p7 lab=ck}
C {lab_pin.sym} 180 -150 0 0 {name=p8 lab=vdd}
C {lab_pin.sym} 180 -130 0 0 {name=p9 lab=vss}
C {lab_pin.sym} 480 -190 0 1 {name=p10 lab=vcn}
C {ipin.sym} 60 -300 0 0 {name=p11 lab=vip}
C {ipin.sym} 60 -280 0 0 {name=p12 lab=vin}
C {ipin.sym} 60 -260 0 0 {name=p13 lab=ck}
C {ipin.sym} 60 -240 0 0 {name=p14 lab=vdd}
C {ipin.sym} 60 -220 0 0 {name=p15 lab=vss}
C {opin.sym} 60 -180 0 0 {name=p16 lab=vcp}
C {opin.sym} 60 -160 0 0 {name=p17 lab=vcn}
